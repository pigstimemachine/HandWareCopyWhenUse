# Keil uVision project TorchSensor.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: task +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\HARDWARE;.\RTE;.\SYSTEM;.\USER;.\SYSTEM\sys;.\SYSTEM\delay;.\SYSTEM\usart;.\HARDWARE\TIMER;.\USER\TaskMgr
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../../../../: DailyRecord.h
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/UART4/: usart.c
  group USER
    ./USER/TaskMgr/: TaskMgr.c
    ./USER/: main.c lib.c
software components: CMSIS:CORE 3.30.0, CMSIS:DSP 1.4.2, Device:Startup 1.0.0
