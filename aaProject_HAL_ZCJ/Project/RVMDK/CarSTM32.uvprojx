# Keil uVision project CarSTM32.uvprojx, settings and files
target portable incubator (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SB +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\FWlib\inc;..\..\User\usart;.\sys;.\delay;..\..\Libraries\CMSIS;..\..\User;..\..\User\gpio;..\..\User\SysTick;..\..\User\Common;..\..\User\ESP8266;..\..\User\Test;..\..\User\dht11;.\usart;..\RVMDK（uv4）;.\KEY;.\time_init;.\LCD;..\..\Libraries\FWlib\inc;..\..\Libraries\FWlib\src;.\wifi;.\NRF24L01;.\SPI;.\TaskMgr;.\TIMER;.\APP;..\RVMDK;.\PWM;.\ResizableArray;..\..\HandWare\ResizableArray;..\..\..\NiceFunctionBOX\Function
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group DOC
    ../../Doc/: readme.txt
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./: main.c
    ../../User/: stm32f10x_conf.h stm32f10x_it.h
    ./delay/: delay.c
    ./sys/: sys.c
    ./TaskMgr/: TaskMgr.c
    ./TIMER/: timer.c
    ./APP/: UAPP_Comm.c
  group HandWare
    ../../../NiceFunctionBOX/Function/: function.c
    ../../../ResizableArray/: ResizableArray.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
